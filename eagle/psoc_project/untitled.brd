# Repository eyallampel1/my_eagle_projects

## EAGLE design eagle/psoc_project/untitled.brd

Parts:
C2, C10, C14: 100NF; C0603
C3, C11, C15: 1UF; C0603
JP1: PINHD-1X2; 1X02
U$1: PSOC_QFN_DEVICE; PSOC_QFN_PACKEGE
U$2: PSOC_10_PIN_HEADER_DEVICE; PSOC_10_PIN_HEADER

Connections:
GND: C2.2, C3.2, C10.2, C11.2, C14.2, C15.2, U$1.EP, U$1.VSS (9), U$1.VSSA (34), U$2.PIN3 (GND), U$2.PIN5 (GND), U$2.PIN7 (GND), U$2.PIN9 (GND)
SWD_CLK0: U$1.P3_3 (13), U$2.PIN4 (SWD_CLK0)
SWD_IO0: U$1.P3_2 (12), U$2.PIN2 (SWD_IO0)
VCC: C2.1, C3.1, C10.1, C11.1, JP1.1, U$1.VDDA (33), U$1.VDDD (32), U$2.PIN1 (3V3_AUX)
VCC2: C14.1, C15.1, JP1.2, U$1.VCCD (31)
XRES: U$1.XRES (30), U$2.PIN10 (XRES)

Board: 2 copper layers, 50.0 x 50.0 mm, 9 parts (0 on the bottom side), 6 nets.

## Commit log

2016-06-15 INITIAL UPLOAD
    INITIAL UPLOAD
